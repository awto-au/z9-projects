File: z9-pdm/vipower.kicad_sch (KiCad schematic)
At the start: 8 parts

Commit message: x
Parts:
- renumbered R2 to R17, R7 to R18, R3 to R19, R223 to R20, R14 to R21, R15 to R22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
